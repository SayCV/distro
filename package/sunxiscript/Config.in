## package/sunxiscript/Config.in
```kconfig
config BR2_PACKAGE_SUNXISCRIPT
	bool "sunxiscript"
	default y
	help
	  Script used for partition init, usb device and other test script.
```
